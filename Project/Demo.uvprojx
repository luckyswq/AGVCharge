# Keil uVision project Demo.uvprojx, settings and files
target CANOpenMaster (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: ..\App;..\Bsp;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\App\pccom;..\App\watchdog;..\App\led;..\App\Stepper;..\App\StateMachine;..\App\MODBUS;..\App\Charge
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group STM32F10x_StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS/Source
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Bsp
    ../Bsp/: bsp.c bsp_timer.c bsp_usart.c bsp_can.c
  group App
    ../App/: main.c stm32f10x_it.c app.c FreeRTOSConfig.h app.h
  group Doc
    ../Doc/: Note.txt
    ../: Readme.md
  group App/pccom
    ../App/pccom/: pccom_app.c pccom_app.h pccom_drv.c pccom_drv.h
  group App/led
    ../App/led/: led_app.h led_app.c
  group App/watchdog
    ../App/watchdog/: watchdog_app.c watchdog_app.h
  group App/stepper
    ../App/Stepper/: modbus_rtu.c modbus_rtu.h serial_queue_app.c serial_queue_app.h stepper_app.c stepper_app.h stepper_drv.c stepper_drv.h stepper_msg.c stepper_msg.h
  group App/statemachine
    ../App/StateMachine/: state_machine_app.c state_machine_app.h
  group App/HMI
    ../App/MODBUS/: HMI_dev.c modbus.C
  group App/Charge
    ../App/Charge/: SoftwareTimer.c
